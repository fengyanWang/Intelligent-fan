# Keil uVision project FanCtl.uvproj, settings and files
target FanCtl (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: FanCtl +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FanCtl
  group Source
    ./: FanCtl.c uart.c TC_Read.c motor.c data_parse.c key.c 18b20.c delay.c
